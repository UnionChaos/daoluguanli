# IAR project IceWarn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZG ST STM32F429ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; USE_HAL_DRIVER; MQTT_TASK
  ICCARM.CCIncludePath2: ..\BSP\Inc; ..\CMSIS; ..\FreeRTOSV10.0.0\Include; ..\Lib\Inc; ..\User; ..\SubMoudle\Debug; ..\SubMoudle\Algorithm; ..\SubMoudle\EEPROM; ..\SubMoudle\SoftI2C; ..\SubMoudle\Pumb; ..\SubMoudle\SIM7600; ..\SubMoudle\Ethernet; ..\SubMoudle\Ethernet\W5500; ..\SubMoudle\DHCP; ..\SubMoudle\MQTT\MQTTPacket; ..\SubMoudle\MQTT; ..\SubMoudle\DataProcess; ..\SubMoudle\localData; ..\SubMoudle\rx8010; ..\SubMoudle\Lora; ..\SubMoudle\lora1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\User
  OBJCOPY.OOCOutputFile: IceWarn.srec
  ILINK.IlinkOutputFile: IceWarn.out
  ILINK.IlinkIcfFile: ..\CMSIS\stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../BSP/Src/: bsp.c bsp_adc.c bsp_can.c bsp_clock.c bsp_led.c bsp_pwr_clk.c bsp_relay.c bsp_spi.c bsp_usart.c
  group CMSIS
    ../CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group FreeRTOS/inc
    ../FreeRTOSV10.0.0/Include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h portasm.s portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group FreeRTOS/src
    ../FreeRTOSV10.0.0/Source/: croutine.c event_groups.c heap_2.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group Lib
    ../Lib/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_timebase_rtc_alarm_template.c stm32f4xx_hal_timebase_rtc_wakeup_template.c stm32f4xx_hal_timebase_tim_template.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group SubMoudle/Algorithm
    ../SubMoudle/Algorithm/: algorithm.c algorithm.h
  group SubMoudle/DataProcess
    ../SubMoudle/DataProcess/: cJSON.c cJSON.h crc.h crc16.c crc32.c DataApp.c DataApp.h DataPub.c DataPub.h GC_protocol.c GC_protocol.h GP_protocol.c GP_protocol.h jsonb_c_base.h jsonb_c_type.h MsgProc.h
  group SubMoudle/DHCP
    ../SubMoudle/DHCP/: dhcp.c dhcp.h
  group SubMoudle/EEPROM
    ../SubMoudle/EEPROM/: EEPROM.c
  group SubMoudle/Ethernet
    ../SubMoudle/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../SubMoudle/Ethernet/W5500/: w5500.c w5500.h
  group SubMoudle/LOCALDATA
    ../SubMoudle/localData/: localdata.c localdata.h
  group SubMoudle/LORA
    ../SubMoudle/lora1/: SX127X_2_Driver.c SX127X_2_Hal.c SX127X_2_Hal.h
    ../SubMoudle/Lora/: SX127X_Driver.c SX127X_Driver.h SX127X_Hal.c SX127X_Hal.h
  group SubMoudle/MQTT
    ../SubMoudle/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
  group SubMoudle/MQTT/MQTTPacket
    ../SubMoudle/MQTT/MQTTPacket/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group SubMoudle/Pumb
    ../SubMoudle/Pumb/: pumb.c pumb.h
  group SubMoudle/RX8010
    ../SubMoudle/rx8010/: rx8010.c rx8010.h softi2c_c.c softi2c_c.h softi2c_port_c.c softi2c_port_c.h
  group SubMoudle/SIM7600
    ../SubMoudle/SIM7600/: mqtt_gprs_interface.c mqtt_gprs_interface.h sim7600.c sim7600.h
  group SubMoudle/SoftIIC
    ../SubMoudle/SoftI2C/: SoftI2C.c SoftI2C.h SoftI2C_port.c SoftI2C_port.h
  group User
    ../User/: AppHook.c eth.c gprs.c includes.h loraApp.c main.c ReadMe.txt stm32f4xx_it.c stm32f4xx_it.h weater.c
